# Keil uVision project pruebas.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: LPC1768 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10007FFF) IRAM2(0x2007C000-0x20083FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: pruebas +hex
  c flags: Optim=1
  c misc: --ASM
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x30000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  group Startup
    ./: system_LPC17xx.c startup_LPC17xx.s
  group Sources
    ./: main.c yo.c
    ./GLCD/: AsciiLib.c GLCD.c
    ./Touch_Pannel/: TouchPanel.c
  group LPC17xx_Libraries
    ./: lpc_types.h LPC17xx.h lpc17xx_gpio.c lpc17xx_gpio.h lpc17xx_libcfg.h lpc17xx_libcfg_default.c lpc17xx_libcfg_default.h lpc17xx_pinsel.c lpc17xx_pinsel.h lpc17xx_clkpwr.c lpc17xx_ssp.c
  group camara
    ./OV7670/: I2C.c OV7670.c OV7670_read.c OV7670_read2.c OV7670_detect.c OV7670_detect2.c calibration.c OV7670_photo.c
  group UART
    ./UART/: uart.c UART_interrup.c
  group TIMER
    ./TIMER/: Timer.c Timer_interrupt.c
  group herramientas
    ./OV7670/: interrupciones.c
    ./herramientas/: herramientas.c
  group SRF04
    ./SRF04/: SRF04.c
  group DAC
    ./DAC/: dac.c
  group DMA
    ./DMA/: dma.c
  group state
    ./State_Machine/: StateMachine.c States.c
  group WEBSERVER
    ./WEBSERVER/Configuration_files/: EMAC_LPC17xx_100Mb.c HTTP_CGI.c HTTP_demo.c Net_Config.c TCP_CM3.lib
    ./WEBSERVER/Web/: Web.inp estilo.css funciones.js index.htm paginas.js Web.c webs.cgi
  group GAMES
    ./GAMES/: games.h caramels.c GAMES.c OV7670_detect_games.c sounds.c
  group SERVOS
    ./SERVOS/: funciones_servos.c Inicio_servos.c interrupciones_servos.c
